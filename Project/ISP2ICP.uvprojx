# Keil uVision project ISP2ICP.uvprojx, settings and files
target ISP2ICP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CH579M WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ISP2ICP +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG
  c include: ..\Driver\StdPeriphDriver\inc;..\Driver\CMSIS\Include;..\Library\inc;..\Driver\Hardware\inc;..\Application\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Driver
    ../Driver/StdPeriphDriver/: CH57x_flash.c CH57x_adc.c CH57x_clk.c CH57x_gpio.c CH57x_int.c CH57x_lcd.c CH57x_pwm.c CH57x_pwr.c CH57x_spi0.c CH57x_spi1.c CH57x_sys.c CH57x_timer0.c CH57x_timer1.c CH57x_timer2.c CH57x_timer3.c CH57x_uart0.c CH57x_uart1.c CH57x_uart2.c CH57x_uart3.c
  group Application
    ../Application/: main.c
  group Startup
    ../Startup/: startup_ARMCM0.s
  group Library
    ../Library/: CH57xNET.LIB
